# Keil uVision project stm32f4.uvprojx, settings and files
target Bobby (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bobby +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\core;.\firmware\inc;.\user\inc;.\board\inc;.\bsp\inc;.\driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/src/: main.c PID.c stm32f4xx_it.c external.c
  group core
    ./core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group firmware
    ./firmware/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group bsp
    ./bsp/src/: BSP_ADC.c BSP_CAN.c BSP_DMA.c BSP_DWT.c BSP_GPIO.c BSP_I2C.c BSP_NVIC.c BSP_SPI.c BSP_TIM.c BSP_UART.c
  group driver
    ./driver/src/: Driver_ADIS16.c Driver_Chassis.c Driver_Dbus.c Driver_Encoder.c Driver_Flash.c Driver_Gimbal.c Driver_Gun.c Driver_Judge.c Driver_Led.c Driver_Menu.c Driver_Monitor.c Driver_MPU6050.c Driver_Simulator.c Driver_ST7735.c
